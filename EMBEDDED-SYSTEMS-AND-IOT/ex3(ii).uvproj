# Keil uVision project ex3(ii).uvproj, settings and files
target Target 1 (MCS-51)
  device: HT83C51 Honeywell
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000)
  output: ex3(ii)
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ex3(ii).asm
